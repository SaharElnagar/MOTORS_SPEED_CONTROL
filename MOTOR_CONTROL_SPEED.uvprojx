# Keil uVision project MOTOR_CONTROL_SPEED.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: QEI
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    R:/TivaWare/driverlib/rvmdk/: driverlib.lib
    ./: startup_TM4C123.s Motor_PWM.c Motor_PWM.h MOTOR_ENCODER.c MOTOR_PID.c MOTOR_ENCODER.h MOTOR_PID.h
